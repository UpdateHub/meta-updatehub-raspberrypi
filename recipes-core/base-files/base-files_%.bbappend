FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

dirs755:append_updatehub-rpi = " /boot/env /data"
